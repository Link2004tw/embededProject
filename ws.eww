<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Embedded_project.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\..\..\..\..\..\Downloads\embededProject-frontend-test\embededProject-frontend-test\main.ewp</path>
    </project>
    <batchBuild />
</workspace>
